# Repository hkustenterprize/RM2025-Wireless-JLink

File README.md:

# 基于嵌入式 Linux 的无线 JLink 烧录器
Wireless JLink-OB based on Allwinner V3S
基于全志科技 V3S 的无线 JLink-OB 烧录器. **完美支持 Ozone, Keil, STM32CubeIDE 等开发软件.**
在网络状态良好情况下, Ozone 内最多可以以 1KHZ Graph 3-4 个变量. 或者以 5Hz 刷新率观测约 50 个值.

实现原理: 在 V3S 上运行自编译的 Linux 系统, 并运行 JLinkRemoteServer 共享挂载在 V3S USB 上的 JLink-OB. 板卡通过 RTL8723 SDIO 网卡联网, 处于同一局域网的电脑可通过输入无线烧录器的 IP 地址进行连接.

**主要参数**
|参数||
|:--|:--|
|尺寸|41x39x5mm|
|JLink版本|JLink-OB|
|接口|4线 SWD接口|
|无线连接距离|5-10m|

**硬件选型**
|参数||
|:--|:--|
|JLink MCU|STM32F103CB|
|嵌入式 Linux Soc|全志 V3S|
|网卡型号|RTL8723|
|电源管理芯片|EA3059|

**电源树**
系统电源较为复杂, 共有 +24V, +5V, +3V3, +3V0, +1V8, +1V2 几种不同电压. 主要由 EA3059 (或 EA3059C) 产生. 其中, V3S 内部供电由蓝色标出, 板上其他外设供电由黄色标出.

**硬件框图**

# 使用方法
> 请注意, 当前版本 SWD 接口的引脚定义与常见 SWD 引脚定义相反. 是笔者的设计失误. 请使用同向 1.25mm 同向线或手动修正线序.

1. 根据下文的固件烧录方法, 烧录 JLink 与 TF 卡固件. 并将 TF 卡插入板子上的 TF 卡座.
2. 电脑打开串口调试助手, 用 Type-C 线连接电脑与 **板子上标有 UART 的 Type-C 座**, 在串口调试助手上打开 CH343 串口. **波特率选择 115200, 数据位 8, 停止位 1, 校验位 None, 无流控**
3. 若硬件一切正常, 固件烧录正确, 将会看到串口调试助手输出以下内容:

```
U-Boot 2017.01-rc2-00057-g32ab1804cd (Sep 30 2024 - 18:54:30 +0800) Allwinner Technology

CPU:   Allwinner V3s (SUN8I 1681)
Model: Lichee Pi Zero
DRAM:  64 MiB

...
Found U-Boot script /boot.scr
reading /boot.scr
...
Starting kernel ...

[    0.000000] Booting Linux on physical CPU 0x0

...
Welcome to ENTERPRIZE buildroot.
```

实际输出可能与给出的示例略有差别, 以打印出 Welcome to ENTERPRIZE buildroot. 为一切正常的标准.
此时的界面为 Linux 命令行登录界面. 账号为 **root**, 密码为 **baoqi**

**Wifi 配置**
首次启动成功后, 请参照如下步骤连接 wifi. 需要注意的是, 路由器需要选择 WPA-EAP/WPA-PSK 加密方式. 其他加密方式需要对应修改 /etc/wpa_supplicant.conf 且笔者实测兼容性较差, 在部分路由器出现认证失败问题无法联网.

1. 编辑 /etc/wpa_supplicant.conf
```conf
ctrl_interface=/var/run/wpa_supplicant
ctrl_interface_group=0
ap_scan=1
network={
    ssid="Your SSID"
    scan_ssid=1
    key_mgmt=WPA-EAP WPA-PSK IEEE8021X NONE
    pairwise=TKIP CCMP
    group=CCMP TKIP WEP104 WEP40
    psk="Your Wifi Password"
    priority=5
}
```

2. 打开 /etc/init.d/wirelessJLinkAutoScript.sh, 并取消相关注释, 最终结果为:
```bash
#!/bin/sh
insmod /lib/modules/r8723bs.ko
ifconfig wlan0 up
wpa_supplicant -B -c /etc/wpa_supplicant.conf -i wlan0
sleep 3s
udhcpc -i wlan0
/root/JLinkARM/JLinkRemoteServerCLExe
```
3. 重启板子, 此时通过串口调试助手观察, 应该会打印出板子对应 IP, 需要并记录此 IP. 同时会显示 Waiting for client connections.. 相关文字, 代表 J-Link Remote Server 已经正常运行.
4. 通过 **交叉 1.25 4Pin 线** 连接无线烧录器 SWD 输出口与目标板.
> 请注意, 当前版本 SWD 接口的引脚定义与常见 SWD 引脚定义相反. 是笔者的设计失误. 请使用同向 1.25mm 同向线或手动修正线序.

5. 以 Ozone 为例, 在同一个局域网内, 输入无线烧录器的 IP 地址即可连接目标板.

> 无线烧录器在车上使用时需要通过 Type-C 或者 XT30 供电. 经测试, 若目标板 SWD 接口有反向供电功能, 不对无线烧录器额外供电也能进行烧录, 但为确保使用稳定性, 仍建议对无线烧录器进行单独供电.

# 固件烧录
目前仅提供 TF 卡烧录相关二进制以及 TF 卡固件编译教程, SPI NOR Flash 镜像仍在调试中. 板子上的 SPI NOR Flash 可以不焊.
> 固件将与编译教程仍在整理中, 将稍后一同开源

**JLink 固件烧录**
参见笔者另一个开源 [【RM2025-地表最小 JLink 开源】香港科技大学 ENTERPRIZE 战队](https://bbs.robomaster.com/article/760967) 中给出的固件以及烧录方法.

**TF 卡固件烧录**
TF 卡要求: 容量 >= 256MByte. 读写速度无要求.
提供完整的固件 dump, 在 ./Firmware/RM2025-WirelessJLink.zip 作为参考. 其 dts, Kernel 等部分可直接复制使用.
Linux 下解压后直接用 dd 命令烧录 ./Firmware/RM2025-WirelessJLink.bin 到 TF 卡.
注意烧录 ./Firmware/RM2025-WirelessJLink.bin 之后需要手动修改网卡 ID 才能正常联网. 具体可根据自动脚本联网时的报错信息自行搜索解决.

# 固件编译
请参考 [固件编译教程](./Docs/LinuxCompileGuide.md)
其中详细地介绍了如何在 
- [荔枝派 UBoot](https://github.com/Lichee-Pi/u-boot/tree/v3s-current)
- [主线 Linux 内核](https://github.com/torvalds/linux) 
- [主线 Buildroot](https://buildroot.org/downloads/buildroot-2019.08.tar.gz)
的基础上一步步配置并编译出我们所需的 UBoot, 最简 Linux Kernel, 最简 Buildroot.

其中也包含了对全过程工具链, 启动流程, 配置思路, Linux 内核设备树, 关于 JLinkRemoteServer 的研究, RTL8723 无线网卡驱动配置, 固件加载等诸多基础内容的介绍.
凝聚了笔者全过程的踩坑经验, 或许是入门嵌入式 Linux 不错的参考.

# 未来更新
已知的硬件 bug:
- SWD 接口的引脚定义与常见 SWD 引脚定义相反. 是笔者的设计失误. 请使用同向 1.25mm 同向线或手动修正线序.

未来版本中会做如下更新:
- 增加锂电池充放电管理, 使之不再依赖于外部供电
- 修改 JLink 相关电路, 缩小体积
- 减少 V3S 滤波电容, 缩小体积

## KiCad design Hardware/WirelessJLink_V3S.kicad_pcb

Parts:
AE1: Antenna_Shield; IPEX_1
C1, C2, C3, C4, C5, C6, C10, C11, C12, C13, C25, C31, C33, C34, C36, C42, C50, C55, C61, C65, C69: 10uF; C_0402_1005Metric
C7, C8, C9, C27, C28: 20pF; C_0402_1005Metric
C14, C15, C16, C17, C18, C19, C23, C26, C29, C30, C35, C37, C38, C39, C41, C44, C45, C46, C51, C52, C53, C56, C57, C58, C59, C62, C66, C67, C68: 100nF; C_0402_1005Metric
C24: 10uF; C_0805_2012Metric
C32, C49, C54, C63, C64: 1uF; C_0402_1005Metric
D1: SMF5V0A; D_SMF
D2: LED; LED_0402_1005Metric
F1: 1A; Fuse_1206_3216Metric
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2_DIN965
J1: Micro_SD_Card; TF_Card_Short2
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4110
J3: JLink_Upload; Hirose_DF13-04P-1.25DS_1x04_P1.25mm_Horizontal
J4: JLink_Upload; 1.25Upload
J5: TFT; 1.47TFT_12P
L1, L2, L3: 4.7uH; L_Sunlord_SWPA252012S
R4, R18: 33R; R_0402_1005Metric
R5, R7, R10, R46: 10K; R_0402_1005Metric
R6, R40: 200K; R_0402_1005Metric
R8: 68K; R_0402_1005Metric
R9: 100K; R_0402_1005Metric
R11: 15K; R_0402_1005Metric
R12, R13: 5.1K; R_0402_1005Metric
R19: 1K; R_0402_1005Metric
R37, R38: 33; R_0402_1005Metric
R39: 240; R_0402_1005Metric
R42, R44: 2K; R_0402_1005Metric
R45: 47K; R_0402_1005Metric
RN1, RN2, RN3: 10K; R_Array_Convex_4x0603
U1: V831; LQFP-128_14x14mm_P0.4mm
U2: HVQFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U4: CH343P; TQFN-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm
U5: STM32F103CBT6; LQFP-48_7x7mm_P0.5mm
U6: HT7133; SOT-23-3
U7: RTL8723BS
Y1: 8MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm
Y2: 24MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+1V2: C2.2, C8.2, C11.2, C13.2, C46.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, L2.2, R7.1, U1.19 (VDD-SYS3), U1.20 (VDD-CPU3), U1.21 (VDD-CPU2), U1.25 (VDD-CPU1), U1.26 (VDD-CPU0), U1.38 (VDD-CPU4), U1.47 (VDD-CPU5), U1.51 (VDD-CPU6), U1.56 (VDD-CPU7), U1.58 (VDD-SYS4), U1.64 (VDD-SYS5), U1.80 (VDD-SYS0), U1.88 (EPHY-VDD), U1.93 (EPHY-VCC), U1.108 (VDD-SYS1), U1.126 (VDD-SYS2)
+1V8: C3.2, C7.2, C10.2, C39.2, C59.1, C62.1, C63.1, C64.1, C65.1, L1.2, R6.1, R44.1, U1.59 (VCC-DRAM8), U1.60 (VCC-DRAM9), U1.61 (VCC-DRAM10), U1.62 (VCC-DRAM11), U1.65 (VCC-DRAM5), U1.66 (VCC-DRAM4), U1.67 (VCC-DRAM3), U1.68 (VCC-DRAM2), U1.69 (VCC-DRAM1), U1.70 (VCC-DRAM0), U1.72 (VCC-DRAM6), U1.79 (VCC-DRAM7)
+3V0: C29.2, C30.2, C31.2, C37.2, U1.76 (VCC-PLL), U1.85 (VCC-MCSI), U1.115 (AVCC), U6.2 (VO)
+3V3: C9.2, C12.2, C14.1, C18.2, C23.1, C24.1, C25.2, C26.2, C35.2, C41.2, C42.2, C57.1, C58.1, C61.1, C66.1, C67.2, C68.1, C69.2, J1.4 (VDD), J3.1, J4.1, J5.9, J5.10, L3.2, R5.1, R8.1, R19.2, R45.2, R46.1, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN3.5 (R4.2), RN3.6 (R3.2), RN3.7 (R2.2), RN3.8 (R1.2), U1.12 (VCC-PE0), U1.29 (VCC-PE1), U1.50 (VCC-IO3), U1.57 (VCC-IO2), U1.98 (VCC-RTC), U1.104 (VCC-IO0), U1.109 (VCC-USB), U1.122 (HPVCCIN), U1.127 (VCC-IO1), U4.1 (VIO), U5.1 (VBAT), U5.9 (VDDA), U5.10 (PA0), U5.24 (VDD), U5.36 (VDD), U5.39 (PB3), U5.48 (VDD), U7.9 (VBAT), U7.22 (VDD_IO)
+5V: C1.1, C4.2, C5.2, C6.2, C16.2, C17.2, C36.2, D1.1 (A1), F1.1, U2.3 (VCC), U2.8 (VIN2), U2.9 (EN2), U2.10 (EN1), U2.11 (VIN1), U2.20 (VIN4), U2.21 (EN4), U2.22 (EN3), U2.23 (VIN3), U4.3 (VDD5), U4.9 (VBUS), U6.3 (VI)
/DXIN: C27.2, U1.74 (X24MOUT), Y2.3
/DXOUT: C28.2, U1.75 (X24MIN), Y2.1
/JLINK_DM: U1.110 (USB-DM), U5.32 (PA11)
/JLINK_DP: U1.111 (USB-DP), U5.33 (PA12)
/JLINK_DXIN: U5.5 (PD0), Y1.3
/JLINK_DXOUT: U5.6 (PD1), Y1.1
/LED_STLINK: D2.1 (K), U5.30 (PA9)
/RESET: C45.2, R45.1, U1.99 (RESET)
/SDC0_CLK: J1.5 (CLK), U1.105 (PF2/SDC0_CLK/UART0_TX)
/SDC0_CMD: J1.3 (CMD), RN3.2 (R2.1), U1.103 (PF3/SDC0_CMD/JTAG_DO1)
/SDC0_D0: J1.7 (DAT0), RN3.1 (R1.1), U1.106 (PF1/SDC0_D0/JTAG_DI1)
/SDC0_D1: J1.8 (DAT1), R5.2, U1.107 (PF0/SDC0_D1/JTAG_MS1)
/SDC0_D2: J1.1 (DAT2), RN3.4 (R4.1), U1.101 (PF5/SDC0_D2/JTAG_CK1)
/SDC0_D3: J1.2 (DAT3/CD), RN3.3 (R3.1), U1.102 (PF4/SDC0_D3/UART0_RX)
/SPI0_CLK: J5.4, U1.53 (PC1/SDC2_CMD/SPI_CLK)
/SPI0_CS: J5.5, U1.54 (PC2/SDC2_RST/SPI_CS)
/SPI0_MOSI: J5.3, U1.55 (PC3/SDC2_D0/SPI_MOSI)
/ST_SWCLK: J4.3, U5.37 (PA14)
/ST_SWDIO: J4.4, U5.34 (PA13)
/TFT_DC: J5.6, U1.45 (PB6/TWI0_SCK/PB_EINT6)
/TFT_RST: J5.2, U1.46 (PB7/TWI0_SDA/PB_EINT7)
/T_JTCK_SWCLK: R18.1, U5.15 (PA5), U5.26 (PB13)
/T_JTMS_SWDIO: R4.1, U5.25 (PB12), U5.27 (PB14)
/UART0_RX: R38.1, U1.49 (PB9/TWI1_SDA/UART0_RX/PB_EINT9)
/UART0_TX: R37.2, U1.48 (PB8/TWI1_SCK/UART0_TX/PB_EINT8)
/UART_DM: J2.A7 (D-), J2.B7 (D-), U4.8 (VD-)
/UART_DP: J2.A6 (D+), J2.B6 (D+), U4.7 (VD+)
/VRA1: C32.2, U1.117 (VRA1)
/VRA2: C33.2, R40.1, U1.118 (VRA2)
/WL_SDIO_CLK: U1.5 (PG0/SDC1_CLK/PG_EINT0), U7.17 (SD_CLK)
/WL_SDIO_CMD: RN2.4 (R4.1), U1.4 (PG1/SDC1_CMD/PG_EINT1), U7.16 (SD_CMD)
/WL_SDIO_D0: RN2.3 (R3.1), U1.3 (PG2/SDC1_D0/PG_EINT2), U7.18 (SD_D0)
/WL_SDIO_D1: RN2.2 (R2.1), U1.2 (PG3/SDC1_D1/PG_EINT3), U7.19 (SD_D1)
/WL_SDIO_D2: RN1.2 (R2.1), U1.1 (PG4/SDC1_D2/PG_EINT4), U7.14 (SD_D2)
/WL_SDIO_D3: RN1.1 (R1.1), U1.128 (PG5/SDC1_D3/PG_EINT5), U7.15 (SD_D3)
GND: AE1.2 (Shield), C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, C11.1, C12.1, C13.1, C14.2, C15.1, C16.1, C17.1, C18.1, C19.1, C23.2, C24.2, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C41.1, C42.1, C44.1, C45.1, C46.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.1, C68.2, C69.1, D1.2 (A2), J1.6 (VSS), J1.9 (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.2, J4.2, J5.1, J5.8, J5.11, J5.12, R9.2, R10.2, R11.2, R12.1, R13.1, R39.1, R40.2, R42.2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
unnamed: AE1.1 (A), U7.2 (ANT)
unnamed: D2.2 (A), R19.1
unnamed: J2.A5 (CC1), R12.2
unnamed: J2.B5 (CC2), R13.2
unnamed: J3.3, R18.2
unnamed: J3.4, R4.2
unnamed: RN1.3 (R3.1), U7.13 (WL_HOST_WAKE)
unnamed: RN1.4 (R4.1), U7.12 (WL_DSI)
unnamed: C44.2, U1.123 (HPVCCBP)
unnamed: C34.2, U1.97 (RTC-VIO)
unnamed: R39.2, U1.73 (SZQ)
unnamed: C7.1, R6.2, R9.1, U2.14 (FB1)
unnamed: C8.1, R7.2, R10.1, U2.5 (FB2)
unnamed: C9.1, R8.2, R11.1, U2.2 (FB3)
unnamed: L1.1, U2.12 (LX1)
unnamed: L2.1, U2.7 (LX2)
unnamed: L3.1, U2.24 (LX3)
unnamed: R37.1, U4.5 (RXD)
unnamed: R38.2, U4.4 (TXD)
unnamed: C15.2, U4.6 (V3)
unnamed: C19.2, U5.7 (NRST)
unnamed: R46.2, U7.34 (BT_DIS)
SVREF: C38.2, C39.1, R42.1, R44.2, U1.63 (SVREF1), U1.71 (SVREF0)
VBUS: F1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)

Notes on the sheet:
PWR
调到1.15V 左右
WIFI
V-IO
正反插功能不同
V-DRAM
使用VBUS供电, IO电平3.3V
V-SYS
必须上拉DSI才能连到
V3S
USB-UART
V-CPU
JLink

Board: 4 copper layers, 24.2 x 42.3 mm, 108 parts (85 on the bottom side), 65 nets.

## Commit log

2025-08-06 Add Hardware & References
2025-08-17 Hardware & Firmware Guide
2025-08-19 编译教程引入
2025-08-19 UBoot
2025-08-26 V2 sch & layout Half Cplt
2025-08-29 Clarify power supply color coding in README
    Updated the power supply section to clarify the color coding for internal and external device power.
2025-09-01 CNC Shell
2025-09-01 V2 Hardware Half Cplt
2025-10-06 V2 Production
2026-04-14 Update Linux Compile Guide
2026-04-14 Add Firmware Bin
